# Keil uVision project CM15.uvprojx, settings and files
target CM15 (6190000::V6.19::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: CM15 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=1
  c define: USE_FULL_LL_DRIVER,STM32F103xE,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/ST7565;../Upper/GUI/Frames;../Upper/GUI/Widgets;../Upper/GUI/Events;../Upper/src;..\Drivers\SSD1322_OLED_lib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c tim.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_gpio.c stm32f1xx_ll_spi.c stm32f1xx_ll_dma.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_ll_pwr.c stm32f1xx_ll_tim.c
  group Drivers/CMSIS
    ./RTE/Device/STM32F103RC/: startup_stm32f10x_hd.s
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/ST7565
    ../Drivers/ST7565/: ST7565.c fonts.c
    ../Drivers/SSD1322_OLED_lib/: SSD1322_API.c SSD1322_GFX.c SSD1322_HW_Driver.c
  group Upper/GUI/PicArray
    ../Upper/GUI/PicArray/: bitmap.c
  group Upper/GUI/Frames
    ../Upper/GUI/Frames/: layout.c mainFrame.c items.c
  group Upper/GUI/Events
    ../Upper/GUI/Events/: eventController.c
  group Upper/GUI/Widgets
    ../Upper/GUI/Widgets/: widgets.c
  group Upper/src
    ../Upper/src/: Spfunc.c coef.c timer.c
software components: CMSIS:CORE 5.6.0
